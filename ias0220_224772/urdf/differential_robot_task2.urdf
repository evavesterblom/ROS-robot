Commit message: add collision properties to passive wheel

File: ias0220_224772/urdf/differential_robot_task2.urdf (robot description, URDF)
Before this commit: robot IAS0220_Evgenia, 7 links, 6 joints
Links:
- link passive_wheel: geometry collision sphere radius=0.01; visual sphere radius=0.01
